# Keil uVision project DQA_main_app_stm32f4.uvproj, settings and files
target DQA_main_app_stm32f4 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DQA_main_app_stm32f4 +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX, __FPU_PRESENT=1
  c include: ..\inc;..\src\rtc;..\src\adc_dma;..\src\cli;..\MDK-ARM;..\src\parameters;..\src\fwupgrade;..\src\sub_dev;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Utilities\STM32F4-Discovery;..\..\..\Utilities\Third_Party\FreeRTOS\Source\include;..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: command.c flash_if.c main.c stm32f4xx_it.c system_stm32f4xx.c usb_bsp.c usbh_usr.c
    ./: retarget.c
    ../inc/: FreeRTOSConfig.h
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_usart.c stm32f4xx_sdio.c
  group MDK-ARM
    ../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32_USB_OTG_Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd_int.c usb_hcd.c
  group STM32_USB_HOST_Library
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
  group FreeRTOS
    ../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group FAT_FS
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c fattime.c
  group daq_log
    ../src/: daq_log.c
  group rtc
    ../src/rtc/: rtc.c
  group STM32F4-Eval
    ../src/rtc/: stm324xg_eval.c
  group adc_dma
    ../src/adc_dma/: adc_dma.c
  group cli
    ../src/cli/: cli.c cli_utils.c cmdline.c
  group fwupgrade
    ../src/fwupgrade/: fwupgrade.c
  group parameters
    ../src/parameters/: eeprom.c parameters.c
  group sub_dev
    ../src/sub_dev/: sub_dev_rx.c
